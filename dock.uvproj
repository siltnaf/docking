# Keil uVision project dock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5202AD STC
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(45000000)
  output: dock +hex (library)
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
